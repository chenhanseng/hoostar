# Keil uVision project Hoostar项目二.uvprojx, settings and files
target Hoostar (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Hoostar_demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\library\Libraries\STM32F10x_StdPeriph_Driver\inc;..\user;..\drivers\inc;..\library\Libraries\CMSIS\CM3\CoreSupport;..\library\Libraries\CMSIS\CM3\DeviceSupport;..\..\hoostar\library\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\hoostar\library\Libraries\CMSIS\CM3\CoreSupport;..\..\hoostar\library\Libraries\CMSIS\CM3\DeviceSupport;..\..\hoostar\user;..\..\hoostar\drivers\inc;E:\系统文件夹.陈\GizwitsMCUSTM32F103C8x2022090700544497980f5a8f\MCU_STM32F103C8x_source\Gizwits;E:\系统文件夹.陈\GizwitsMCUSTM32F103C8x2022090700544497980f5a8f\MCU_STM32F103C8x_source\Utils
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group user
    ../user/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group doc
    ../doc/: ReadMe.txt
  group libraries
    ../library/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group starup
    ../library/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../library/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../library/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
  group drivers
    ../drivers/src/: SysTick.c UART.c NVIC.c TIM.c IIC.c DHT11.c oled.c ADC.c DMA.c
  group Gizwits
    ../drivers/src/: gizwits_product.c gizwits_protocol.c
  group Utils
    ../drivers/src/: common.c dataPointTools.c ringbuffer.c
